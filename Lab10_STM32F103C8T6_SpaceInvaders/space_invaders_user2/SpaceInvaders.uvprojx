# Keil uVision project SpaceInvaders.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SpaceInvaders +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  asm include: ..\Lab10_SpaceInvaders
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c ADC.c Timer.c IO.c UART.c PLL.c UART.s UART2_INIT.s UART2_INIT.h uart2_functions.s SYSTICK.c SysTick.h
  group Lib
    ./: ADC.h Timer.h IO.h UART.h PLL.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
